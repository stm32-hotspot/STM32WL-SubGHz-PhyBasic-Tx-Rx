<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SubGHz_Phy_Basic_LoRa.ewp</path>
  </project>
  <batchBuild />
</workspace>
